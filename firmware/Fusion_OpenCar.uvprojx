# Keil uVision project Fusion_OpenCar.uvprojx, settings and files
target Fusion_OpenCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fusion_OpenCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\App;.\Hardware;.\Driver\CMSIS;.\Driver\StdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/: app_chassis.c app_chassis.h app_config.h app_link.c app_link.h app_vision.c app_vision.h app_main.c stm32f4xx_it.c
  group Hardware
    ./Hardware/: adc.c clock.c encoder.c i2c_soft.c imu.c io.c motor.c screen.c serial.c board.h adc.h clock.h encoder.h font.h i2c_soft.h imu.h imu_reg.h io.h motor.h screen.h serial.h vision_uart.c vision_uart.h
  group StdPeriph_Driver
    ./Driver/StdPeriph/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ./Driver/CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
